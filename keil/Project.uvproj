# Keil uVision project Project.uvproj, settings and files
target Project (MCS-51)
  device: CMS8F003 Cmsemicon
  cpu: IRAM(0 - 0xFF) IROM(0-0x1FFF) XRAM(0x0000-0x00FF) CLOCK(16000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\code;..\..\Libary\StdDriver\inc;..\..\Libary\Device\CMS8F003\Include
  link misc: REMOVEUNUSED
  group CMS
    ../../Libary/Device/CMS8F003/: startup_cms8f003.A51
    ../../Libary/Device/CMS8F003/Include/: cms8f003.h
  group LIB
    ../../Libary/StdDriver/src/: gpio.c uart.c
  group User
    ../code/: isr.c main.c iic.c timer.c
